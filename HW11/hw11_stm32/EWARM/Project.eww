<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\hw11_stm32.ewp</path>
  </project>
  <batchBuild />
</workspace>
